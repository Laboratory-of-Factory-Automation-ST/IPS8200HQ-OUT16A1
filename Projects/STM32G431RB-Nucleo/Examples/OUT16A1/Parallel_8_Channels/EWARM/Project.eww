<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Parallel_8_Channels.ewp</path>
  </project>
  <batchBuild />
</workspace>
